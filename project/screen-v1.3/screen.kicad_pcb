# Repository onlinelei/KICAD (continued)

## KiCad design project/NodeMcu/NodeMcu.kicad_pcb

Parts:
C1: 100uf; CASE-B_3528
C2, C7, C9: 10uf; C_0402_1005Metric
C3, C4: 100nf; C_0402_1005Metric
C5: 1uf; C_0402_1005Metric
C6, C8: 470pf; C_0402_1005Metric
D1: 3.3; LED_0201_0603Metric
D2: TXD; LED_0201_0603Metric
D3: RXD; LED_0201_0603Metric
D4: B120-E3; D_SOD-123
J1: J1; PinHeader_1x15_P2.54mm_Vertical
J2: J2; PinHeader_1x15_P2.54mm_Vertical
J3: usbc; USB_C_Receptacle_HRO_TYPE-C-31-M-12
Q1: q1; TSOT-23
Q2: q2; TSOT-23
R1, R7, R9, R12, R13: 470; R_0402_1005Metric
R2, R3, R10, R11, R14, R15: 12K; R_0402_1005Metric
R4, R5: 1k; R_0402_1005Metric
R6: 12k; R_0402_1005Metric
R8: 0; R_0402_1005Metric
R16: 220K(1%); R_0402_1005Metric
R17: 100K(1%); R_0402_1005Metric
SW1, SW2: SW_Push; SMD,3x4x2mm
U1: ESP-12E
U2: SPX3819M5-L-3-3; SOT-23-5
U3: CH340C; SOP-16_150MIL

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, C7.1, C9.1, J1.5, J1.7, J2.1, J2.10, R1.1, R2.2, R3.2, R4.1, R5.1, R6.2, R10.2, U1.8 (VCC), U2.5 (OUT), U3.4 (V3), U3.16 (VCC)
+5VD: C5.1, D4.1 (K), U2.1 (IN), U2.3 (EN)
/ADC: J1.14, R16.1, R17.1, U1.2 (ADC)
/ADC EX: J1.15, R16.2
/EN: J1.4, R6.1, U1.3 (EN)
/GPIO0: J2.12, Q2.3 (C), R2.1, R9.1, U1.18 (GPIO0)
/GPIO2: J2.11, R3.1, U1.17 (GPIO2)
/GPIO4: J2.13, U1.19 (GPIO4)
/GPIO5: J2.14, U1.20 (GPIO5)
/GPIO12: J2.7, U1.6 (GPIO12)
/GPIO13: J2.6, U1.7 (GPIO13)
/GPIO14: J2.8, U1.5 (GPIO14)
/GPIO15: J2.5, R11.1, U1.16 (GPIO15)
/GPIO16: D1.1 (K), J2.15, R7.1, U1.4 (GPIO16)
/RXD: D3.1 (K), J2.4, R12.1, U1.21 (GPIO3/RXD)
/TXD: D2.1 (K), J2.3, R13.2, U1.22 (GPIO1/TXD)
/VDDUSB: D4.2 (A), J1.1, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS)
/nRST: C8.2, J1.3, Q1.3 (C), R8.1, R10.1, U1.1 (~RST)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.1, C9.2, J1.2, J1.6, J1.8, J2.2, J2.9, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), R11.2, R17.2, SW1.2, SW2.2, U1.15 (GND), U2.2 (GND), U3.1 (GND)
unnamed: C6.1, U2.4 (BP)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: J3.A6 (D+), J3.B6 (D+), U3.5 (UD+)
unnamed: J3.A7 (D-), J3.B7 (D-), U3.6 (UD-)
unnamed: Q1.1 (B), R14.1
unnamed: Q1.2 (E), R15.2, U3.14 (~RTS)
unnamed: Q2.1 (B), R15.1
unnamed: Q2.2 (E), R14.2, U3.13 (~DTR)
unnamed: R7.2, R8.2, SW1.1
unnamed: R9.2, SW2.1
unnamed: R12.2, U3.2 (TXD)
unnamed: R13.1, U3.3 (RXD)

Notes on the sheet:
SP-12
ONNECT
KEY-LED
USB-UART
D10
POWER

Board: 2 copper layers, 49.0 x 29.0 mm, 40 parts (0 on the bottom side), 33 nets.

## KiCad design screen/screen.kicad_pcb

Board: 4 copper layers, 41.9 x 30.0 mm, 34 parts (1 on the bottom side), 25 nets.

Parts:
C1, C2: 470pf; C_0402_1005Metric
C3: 100uf; CASE-B_3528
C4: 1uf; C_0402_1005Metric
C5, C6, C7: 10uf; C_0402_1005Metric
D1: led-white; LED_0402_1005Metric
D2: led-green; LED_0402_1005Metric
D3: led-red; LED_0402_1005Metric
J1: USB_C_Receptacle_USB2.0; USB_C_6pin
J2: Conn_01x06_Female; PinHeader_1x06_P1.27mm_Vertical
J3: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x12_Female; TFT_1.4_12_front
R1, R2, R3, R7: 12K; R_0402_1005Metric
R4, R10, R11: 470; R_0402_1005Metric
R5: 1.2K; R_0402_1005Metric
R6: 0; R_0402_1005Metric
R8, R13: 10k; R_0402_1005Metric
R9, R14: 1k; R_0402_1005Metric
R12: 12k; R_0402_1005Metric
SW1, SW2: SW_Push; Button_SMD,3x4x2mm
SW3: SW_DPDT_x2; SW_SPDT_PCM12
U1: ESP-12E
U2: TP4056_[C16581]; SOP-8_EP_150MIL
U3: SPX3819M5-L-3-3; SOT-23-5

Connections:
+3V3: C3.1, C7.1, J2.1, J4.3, J4.4, R2.2, R3.2, R7.2, R10.1, R12.2, U1.8 (VCC), U3.5 (OUT)
+BATT: C6.1, J3.1, R13.2, SW3.1 (A), U2.5 (BAT), U3.1 (IN)
/ADC: R8.2, R13.1, U1.2 (ADC)
/EN: R12.1, U1.3 (EN)
/GPIO0: J2.4, J4.7, R2.1, R4.1, U1.18 (GPIO0)
/GPIO2: R3.1, U1.17 (GPIO2)
/GPIO13: J4.10, U1.7 (GPIO13)
/GPIO14: J4.9, U1.5 (GPIO14)
/GPIO15: R1.1, U1.16 (GPIO15)
/GPIO16: D1.1 (K), R6.1, U1.4 (GPIO16)
/RXD: J2.6, U1.21 (GPIO3/RXD)
/TXD: J2.5, U1.22 (GPIO1/TXD)
/nRST: C1.2, J2.3, J4.11, R7.1, R11.1, U1.1 (~RST)
GND: C1.1, C2.2, C3.2, C4.2, C5.1, C6.2, C7.2, J1.A12 (GND), J1.B12 (GND), J2.2, J3.2, J4.1, J4.2, J4.5, J4.6, J4.12, R1.2, R5.2, R8.1, SW1.2, SW2.2, U1.15 (GND), U2.1 (TEMP), U2.3 (GND), U3.2 (GND)
unnamed: C5.2, J1.A9 (VBUS), J1.B9 (VBUS), R9.2, R14.2, U2.4 (VCC), U2.8 (CE)
unnamed: C4.1, SW3.2 (B), U3.3 (EN)
unnamed: C2.1, U3.4 (BP)
unnamed: D3.1 (K), U2.7 (~CHRG)
unnamed: D3.2 (A), R9.1
unnamed: D1.2 (A), R10.2
unnamed: D2.1 (K), U2.6 (~STDBY)
unnamed: D2.2 (A), R14.1
unnamed: R5.1, U2.2 (PROG)
unnamed: R6.2, R11.2, SW2.1
unnamed: R4.2, SW1.1

## KiCad design NodeMcu_V1.0/NodeMcu_v1.0.kicad_pcb

Parts:
C1: 100uf; CASE-B_3528
C2, C6, C7: 100nf; C_0402_1005Metric
C3: 10uf 25v; C_0805_2012Metric
C4, C5, C8: 10uf; C_0402_1005Metric
D1: 3.3; C_0603_1608Metric
D2: TXD; C_0603_1608Metric
D3: RXD; C_0603_1608Metric
D4: B120-E3; D_SOD-123
J1: J2; PinHeader_1x15_P2.54mm_Vertical
J2: J1; PinHeader_1x15_P2.54mm_Vertical
J3: usbc; USB_C_Receptacle_HRO_TYPE-C-31-M-12
Q1: q1; SOT-23
Q2: q2; SOT-23
R1, R3, R10, R11, R12, R14: 12K; C_0402_1005Metric
R2, R8, R9, R13: 470; C_0402_1005Metric
R4, R5: 1k; C_0402_1005Metric
R6: 12k; C_0402_1005Metric
R7: 0; C_0402_1005Metric
R16: 220K(1%); C_0402_1005Metric
R17: 100K(1%); C_0402_1005Metric
SW1, SW2: SW_Push; SMD,3x4x2mm
U1: ESP-12E
U2: NCP1117-1.5_SOT223; SOT-223
U3: CP2102-GMR_[C6568]; QFN-28-1EP_5x5mm_P0.5mm_EP3.35x3.35mm

Connections:
+3V3: C1.1, C4.1, C5.1, C6.1, J1.11, J2.6, J2.15, R1.2, R2.1, R3.2, R4.1, R5.1, R6.2, R10.2, U1.8 (VCC), U2.2 (VO), U3.6 (VDD), U3.7 (REGIN)
+5VD: C3.1, D4.1 (K), U2.3 (VI)
/ACTIVE: U3.11 (~SUSPEND)
/ADC: J1.2, R16.1, R17.1, U1.2 (ADC)
/ADC EX: J1.1, R16.2
/CTS: U3.23 (CTS)
/DCD: U3.1 (DCD)
/DSR: U3.27 (DSR)
/EN: J1.12, R6.1, U1.3 (EN)
/GPIO0: J2.4, Q2.3 (C), R1.1, R9.1, U1.18 (GPIO0)
/GPIO2: J2.5, R3.1, U1.17 (GPIO2)
/GPIO4: J2.3, U1.19 (GPIO4)
/GPIO5: J2.2, U1.20 (GPIO5)
/GPIO9: J1.5, U1.11 (GPIO9)
/GPIO10: J1.4, U1.12 (GPIO10)
/GPIO12: J2.9, U1.6 (GPIO12)
/GPIO13: J2.10, U1.7 (GPIO13)
/GPIO14: J2.8, U1.5 (GPIO14)
/GPIO15: J2.11, R11.1, U1.16 (GPIO15)
/GPIO16: D1.1 (K), J2.1, R7.1, U1.4 (GPIO16)
/RI: U3.2 (RI)
/RXD: D3.1 (K), J2.12, R13.1, U1.21 (GPIO3/RXD)
/SPI_CLK: J1.9, U1.14 (SCLK)
/SPI_INT: J1.6, U1.13 (MOSI)
/SPI_MISO: J1.8, U1.10 (MISO)
/SPI_MOSI: J1.7, U1.9 (CS0)
/TXD: D2.1 (K), J2.13, U1.22 (GPIO1/TXD), U3.25 (RXD)
/VDDUSB: C7.1, C8.1, D4.2 (A), J1.15, J3.A4 (VBUS), J3.A9 (VBUS), J3.B4 (VBUS), J3.B9 (VBUS), U3.8 (VBUS)
/nRST: C2.2, J1.13, Q1.3 (C), R8.1, R10.1, U1.1 (~RST)
GND: C1.2, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, J1.10, J1.14, J2.7, J2.14, J3.A1 (GND), J3.A12 (GND), J3.B1 (GND), J3.B12 (GND), J3.S1 (SHIELD), R11.2, R17.2, SW1.2, SW2.2, U1.15 (GND), U2.1 (GND), U3.3 (GND)
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R4.2
unnamed: D3.2 (A), R5.2
unnamed: J3.A6 (D+), J3.B6 (D+), U3.4 (D+)
unnamed: J3.A7 (D-), J3.B7 (D-), U3.5 (D-)
unnamed: Q1.1 (B), R12.1
unnamed: Q1.2 (E), R14.2, U3.24 (RTS)
unnamed: Q2.1 (B), R14.1
unnamed: Q2.2 (E), R12.2, U3.28 (DTR)
unnamed: R7.2, R8.2, SW1.1
unnamed: R9.2, SW2.1
unnamed: R13.2, U3.26 (TXD)

Notes on the sheet:
USB-UART
KEY-LED
ONNECT
注意：（每次启动、重启、唤醒） GPIO15 必须保持低电平，GPIO2 必须 保持高电平 GPIO0 高电平->运行模式，低电平->刷写模式 如果需要用到sleep 模式，GPIO16 和 RST 必须连接，GPIO16 会输出低电平唤醒系统
SP-12
POWER
D10

Board: 2 copper layers, 38 parts (0 on the bottom side), 37 nets, no tracks yet.

## KiCad design USB-TTL/Usb-ttl.kicad_pcb

Board: 2 copper layers, 25.0 x 16.0 mm, 9 parts (0 on the bottom side), 10 nets.

Parts:
C1, C2: C; C_0603_1608Metric
D1, D2: LED; LED_0603_1608Metric
J1: USB_A; USB_A_CNCTech_1001-011-01101_Horizontal
J2: Conn_01x05; PinHeader_1x05_P2.54mm_Horizontal
R1, R2: 4.7K; R_0603_1608Metric
U1: CH330N; SOIC-8_3.9x4.9mm_P1.27mm

Connections:
+5V: C1.1, J1.1, J2.5, R1.1, R2.1, U1.5
/D+: J1.3, U1.1
/D-: J1.2, U1.2
/RTS: J2.1, U1.4
/RXD: D2.1, J2.3, U1.7
/TXD: D1.1, J2.4, U1.6
GND: C1.2, C2.2, J1.4, J1.5, J2.2, U1.3
unnamed: C2.1, U1.8
unnamed: D1.2, R1.2
unnamed: D2.2, R2.2

## Commit log

2022-01-16 nodemcu
2022-01-17 add cu
2022-01-18 bom gerber
2022-01-19 add ignore
2022-01-19 finish
2022-01-19 generator gable
2022-01-20 new screen project
2022-01-20 update screen
2022-01-25 add tft footprint
2022-01-25 finish tft screen
2022-02-02 screen finish
2022-02-07 esp8266
2022-02-08 update my foot prints
2022-02-08 add plagins
2022-02-08 add usb-c vi
2022-02-09 add tft 0.98
2022-02-09 feat: screen v1.2
2022-02-09 feat: add 0.98 TFT
2022-02-10 feat: update esp8266ex
2022-02-10 feat 1. add 2.4G wifi 2. update esp8266 board
2022-02-11 feat: update esp 8266
2022-02-11 feat: esp8266 gerber
2022-02-12 feat: 1.finish esp8266ex 2.finish usb ttl
2022-02-13 feat: power bank
2022-02-14 feat:add screen 0.96 project
2022-02-19 fix: screen rst and cs
2022-02-22 feat: update screen v1.3
2022-02-23 feat: update usb - ttl
2022-02-28 feat: screen v1.3 done
2022-03-06 fix: update screen usb-ttl
2022-04-28 add somthing
