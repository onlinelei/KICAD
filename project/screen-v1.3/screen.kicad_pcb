# Repository onlinelei/KICAD

## KiCad design project/screen-v1.3/screen.kicad_pcb

Parts:
C1: 100uf; CASE-B_3528
C2: 1uf; C_0402_1005Metric
C3, C5: 470pf; C_0402_1005Metric
C4, C6, C7: 10uf; C_0402_1005Metric
D1: led-white; LED_0402_1005Metric
D2: led-red; LED_0402_1005Metric
D3: led-green; LED_0402_1005Metric
J1: TTL-connect-pin4; PinHeader_1x05_P2.00mm_Vertical
J2: USB_C_6pin
J3: Conn_01x02_Female; PinHeader_1x02_P2.54mm_Vertical
Q1: S8050; SOT-23
R1, R3, R4, R8, R9, R16: 12K; R_0402_1005Metric
R2, R6, R7: 470; R_0402_1005Metric
R5: 0; R_0402_1005Metric
R10, R12: 1k; R_0402_1005Metric
R11: 2K; R_0402_1005Metric
R13: 100k; R_0402_1005Metric
R14: 330K; R_0402_1005Metric
R15: 1K; R_0402_1005Metric
SW1: SW_DPDT_x2; SW_SPDT_PCM12
SW2, SW3: SW_Push; Button_SMD,3x4x2mm
U1: SPX3819M5-L-3-3; SOT-23-5
U2: ESP-12E
U3: TFT_1.3_12; TFT_1.3_12_front
U4: TP4056_[C16581]; SOP-8_EP_150MIL

Connections:
+3V3: C1.1, C4.1, R1.2, R2.1, R3.2, R4.2, R8.2, R16.1, U1.5 (OUT), U2.8 (VCC), U3.3 (LEDA), U3.4 (VDD)
+BATT: C7.1, J3.1, R13.2, SW1.1 (A), U1.1 (IN), U4.5 (BAT)
/ADC: R13.1, R14.2, U2.2 (ADC)
/EN: J1.5 (RST), R4.1, U2.3 (EN)
/GPIO0: J1.2 (GPIO0), R1.1, R7.1, U2.18 (GPIO0), U3.7 (D/C)
/GPIO2: R3.1, U2.17 (GPIO2), U3.11 (RESET)
/GPIO4: U2.19 (GPIO4)
/GPIO5: R15.1, U2.20 (GPIO5)
/GPIO12: U2.6 (GPIO12)
/GPIO13: U2.7 (GPIO13), U3.10 (SDA)
/GPIO14: U2.5 (GPIO14), U3.9 (SCL)
/GPIO15: R9.1, U2.16 (GPIO15)
/GPIO16: D1.1 (K), R5.1, U2.4 (GPIO16)
/RXD: J1.3 (RXD), U2.21 (GPIO3/RXD)
/TXD: J1.4 (TXD), U2.22 (GPIO1/TXD)
/nRST: C5.2, R6.1, R8.1, U2.1 (~RST)
GND: C1.2, C2.2, C3.2, C4.2, C5.1, C6.1, C7.2, J1.1 (GND), J2.A12 (GND), J2.B12 (GND), J2.S1 (SHIELD), J3.2, Q1.2 (E), R9.2, R11.2, R14.1, SW2.2, SW3.2, U1.2 (GND), U2.15 (GND), U3.1 (GND), U3.5 (GND), U3.6 (GND), U3.8 (CS), U3.12 (GND), U4.0, U4.1 (TEMP), U4.3 (GND)
unnamed: C2.1, SW1.2 (B), U1.3 (EN)
unnamed: C3.1, U1.4 (BP)
unnamed: C6.2, J2.A9 (VBUS), J2.B9 (VBUS), R10.2, R12.2, U4.4 (VCC), U4.8 (CE)
unnamed: D1.2 (A), R2.2
unnamed: D2.1 (K), U4.7 (~CHRG)
unnamed: D2.2 (A), R10.1
unnamed: D3.1 (K), U4.6 (~STDBY)
unnamed: D3.2 (A), R12.1
unnamed: Q1.1 (B), R15.2, R16.2
unnamed: Q1.3 (C), U3.2 (LEDK)
unnamed: R5.2, R6.2, SW2.1
unnamed: R7.2, SW3.1
unnamed: R11.1, U4.2 (PROG)

Notes on the sheet:
KEY-LED
POWER
USB-TTL
注意：（每次启动、重启、唤醒） GPIO15 必须保持低电平，GPIO2 必须 保持高电平 GPIO0 高电平->运行模式，低电平->刷写模式 如果需要用到sleep 模式，GPIO16 和 RST 必须连接， GPIO16 会输出低电平唤醒系统
CHARGE
BATTERY
SCREEN
SP-12

Board: 4 copper layers, 41.9 x 30.0 mm, 37 parts (1 on the bottom side), 28 nets.

## KiCad design project/PlantCare/PlantCare.kicad_pcb

Parts:
C1: 100uf; CASE-B_3528
C4: 470pf; C_0402_1005Metric
D1, D2, D3: led-white; LED_0402_1005Metric
H1, H2, H3, H4: MountingHole; MountingHole_2.5mm_Pad_Via
J1: TFT_0.96_13; TFT_0.96_13_front
J2: TTL-connect-pin4; PinHeader_1x05_P2.00mm_Vertical
J3, J4, J5: Conn_01x02_Female; Connect_push_5mm
Q1: S8050; SOT-23
Q2, Q4: Q_NMOS_GSD; TSOT-23
R1, R3, R4, R8, R9, R11, R12, R13: 12K; R_0402_1005Metric
R2, R6, R7: 470; R_0402_1005Metric
R5: 0; R_0402_1005Metric
R10: 1K; R_0402_1005Metric
SW2, SW3: SW_Push; Button_SMD,3x4x2mm
U2: ESP-12E

Connections:
+3V3: C1.1, J1.10 (VCC), J1.12 (LEDA), R1.2, R2.1, R3.2, R4.2, R8.2, R13.1, U2.8 (VCC); also elsewhere on the board
+BATT: J3.2, J4.1, J5.2, R11.1, R12.1; also elsewhere on the board
/ADC: U2.2 (ADC)
/EN: J2.5 (RST), R4.1, U2.3 (EN)
/GPIO0: J1.5 (RS), J2.2 (GPIO0), R1.1, R7.1, U2.18 (GPIO0)
/GPIO2: J1.6 (RES), R3.1, U2.17 (GPIO2)
/GPIO4: Q4.1 (G), U2.19 (GPIO4)
/GPIO5: R10.1, U2.20 (GPIO5)
/GPIO12: Q2.1 (G), U2.6 (GPIO12)
/GPIO13: J1.3 (SDA), U2.7 (GPIO13)
/GPIO14: J1.4 (SCL), U2.5 (GPIO14)
/GPIO15: R9.1, U2.16 (GPIO15)
/GPIO16: D1.1 (K), R5.1, U2.4 (GPIO16)
/RXD: J2.3 (RXD), U2.21 (GPIO3/RXD)
/TXD: J2.4 (TXD), U2.22 (GPIO1/TXD)
/control: D2.1 (K), J5.1, Q4.3 (D)
/control1: D3.1 (K), J3.1, Q2.3 (D)
/nRST: C4.2, R6.1, R8.1, U2.1 (~RST)
GND: C1.2, C4.1, J1.7 (CS), J1.8 (GND), J1.13 (GND), J2.1 (GND), J4.2, Q1.2 (E), Q2.2 (S), Q4.2 (S), R9.2, SW2.2, SW3.2, U2.15 (GND); also elsewhere on the board
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R11.2
unnamed: D3.2 (A), R12.2
unnamed: J1.11 (LEDK), Q1.3 (C)
unnamed: Q1.1 (B), R10.2, R13.2
unnamed: R5.2, R6.2, SW2.1
unnamed: R7.2, SW3.1

Notes on the sheet:
SCREEN
v1.1 改动 1. AMS1117留4个位置，并联，可以不用。 2. 烧录器，LED位置可以不用。 3. 按键 led 电路可以放在背板不用放置元件 4. 被控制电路接LED显示开关状态 5. 去掉usb-uart 6. 增加一路控制 7. 烧录接口改成5pin 8. 连接电池，电机，改成接线柱连接
POWER
KEY-LED
SP-12
USB-UART
USB-TTL
BATTERY
MOTO
注意：（每次启动、重启、唤醒） GPIO15 必须保持低电平，GPIO2 必须 保持高电平 GPIO0 高电平->运行模式，低电平->刷写模式 如果需要用到sleep 模式，GPIO16 和 RST 必须连接， GPIO16 会输出低电平唤醒系统

Parts:
C2, C3, C8, C9, C10, C11: 10uf; C_0402_1005Metric
R14: 100k; R_0402_1005Metric
R15: 330k; R_0402_1005Metric
SW1: SW_DPDT_x2; SW_SPDT_PCM12
U1, U4, U5: AMS1117-3.3; SOT-223-3_TabPin2

Connections:
+3V3: C2.1, C8.1, C10.1, U1.2 (VO), U4.2 (VO), U5.2 (VO); also elsewhere on the board
+BATT: SW1.1 (A); also elsewhere on the board
/POWER/ADC: R14.2, R15.1
GND: C2.2, C3.2, C8.2, C9.2, C10.2, C11.2, R14.1, U1.1 (GND), U4.1 (GND), U5.1 (GND); also elsewhere on the board
unnamed: C3.1, C9.1, C11.1, R15.2, SW1.2 (B), U1.3 (VI), U4.3 (VI), U5.3 (VI)

Board: 4 copper layers, 81.0 x 56.1 mm, 45 parts (7 on the bottom side), 27 nets.

## KiCad design project/USB-TTL-V1/USB-TTL-V1.kicad_pcb

Parts:
C1: 10uf; C_0402_1005Metric
C2, C3: 100nf; C_0402_1005Metric
D2: TXD; LED_0402_1005Metric
D3: RXD; LED_0402_1005Metric
J1: TTL-connect-pin4; PinHeader_1x05_P2.00mm_Vertical
J2: usbc; USB_C_Receptacle_HRO_TYPE-C-31-M-12
Q1, Q2: S8050; TSOT-23
R3, R4, R5, R6: 12K; R_0402_1005Metric
U1: CH340C; SOP-16_150MIL

Connections:
+5V: C1.1, C2.1, J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS), R5.1, R6.1, U1.16 (VCC)
/EN: J1.5 (RST), Q1.3 (C)
/GPIO0: J1.2 (GPIO0), Q2.3 (C)
/RXD: D3.1 (K), J1.3 (RXD), U1.2 (TXD)
/TXD: D2.1 (K), J1.4 (TXD), U1.3 (RXD)
GND: C1.2, C2.2, C3.2, J1.1 (GND), J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), U1.1 (GND)
unnamed: C3.1, U1.4 (V3)
unnamed: D2.2 (A), R5.2
unnamed: D3.2 (A), R6.2
unnamed: J2.A6 (D+), J2.B6 (D+), U1.5 (UD+)
unnamed: J2.A7 (D-), J2.B7 (D-), U1.6 (UD-)
unnamed: Q1.1 (B), R3.1
unnamed: Q1.2 (E), R4.2, U1.14 (~RTS)
unnamed: Q2.1 (B), R4.1
unnamed: Q2.2 (E), R3.2, U1.13 (~DTR)

Notes on the sheet:
LED
USB-UART
USB-TTL

Board: 4 copper layers, 23.9 x 11.3 mm, 14 parts (0 on the bottom side), 15 nets.

## KiCad design project/esp8266-V1/esp8266.kicad_pcb

Parts:
C1: 100uf; CASE-B_3528
C2: 1uF; C_0402_1005Metric
C3: 10uF; C_0402_1005Metric
C4: 0.1uF; C_0402_1005Metric
C5: 8.2pF; C_0402_1005Metric
C6: 2.4pF; C_0402_1005Metric
C7: 470pf; C_0402_1005Metric
C8, C9: 10pF; C_0402_1005Metric
D1: 3.3; LED_0402_1005Metric
D2: TXD; LED_0402_1005Metric
D3: RXD; LED_0402_1005Metric
E1: ANTENNA-GROUNDEDTRACE-15.2MM; RF_2.4GHZ_15.2MM
J1: power; PinHeader_1x02_P2.54mm_Vertical
J2: TTL; PinHeader_1x06_P1.27mm_Vertical
J3, J4: Conn_01x15_Female; PinHeader_1x15_P2.54mm_Vertical
L1: 1.5nH; L_0402_1005Metric
R1, R3, R4, R11, R12: 12K; R_0402_1005Metric
R2, R9, R10: 470; R_0402_1005Metric
R5, R6: 1k; R_0402_1005Metric
R7: 12k; R_0402_1005Metric
R8: 0; R_0402_1005Metric
R13, R14: 10K; R_0402_1005Metric
R15: 50; R_0402_1005Metric
SW1: RST; Button_SMD,3x4x2mm
SW2: Flash; Button_SMD,3x4x2mm
U1: ESP8266EX; QFN-32-1EP_5x5mm_P0.5mm_EP3.45x3.45mm
U2: Flash_SOP-8_150mil; SOP-8_150MIL
Y1: 26MHz; SMD-3225_4P

Connections:
/ADC_IN: J4.1, U1.6 (TOUT)
/CHIP_PU: J4.2, R7.1, U1.7 (CHIP_PU)
/CMD/MOSI: J4.10, U1.20 (SDIO_CMD)
/GPIO0: J2.4, J4.6, R1.1, R10.1, U1.15 (GPIO0)
/GPIO2: J4.5, R4.1, U1.14 (GPIO2)
/GPIO4: J4.7, U1.16 (GPIO4)
/GPIO5: J4.14, U1.24 (GPIO5)
/GPIO16: D1.1 (K), J4.3, R8.1, U1.8 (XPD_DCDC)
/MTCK: U1.12 (MTCK), U2.5 (SI)
/MTDI: U1.10 (MTDI), U2.2 (SO)
/MTDO: R12.1, U1.13 (MTDO), U2.1 (CS)
/MTMS: J4.4, R15.2, U1.9 (MTMS)
/RST: C7.2, J2.3, R9.1, R11.1, U1.32 (~EXT_RSTB)
/RXD: D3.1 (K), J2.6, U1.25 (U0RXD)
/SCLK: J4.11, U1.21 (SDIO_CLK)
/SD0/MISO: J4.12, U1.22 (SDIO_DATA_0)
/SD1/INT: J4.13, U1.23 (SDIO_DATA_1)
/SD2/GPIO9: J4.8, U1.18 (SDIO_DATA_2)
/SD3/CS: J4.9, U1.19 (SDIO_DATA_3)
/TXD: D2.1 (K), J2.5, U1.26 (U0TXD)
GND: C1.2, C2.1, C3.1, C4.1, C6.1, C7.1, C8.1, C9.1, E1.GND, J1.2, J2.2, L1.2, R3.1, R12.2, SW1.2, SW2.2, U1.33 (GND), U2.4 (GND), Y1.2, Y1.4
unnamed: C5.1, C6.2, E1.ANT (SIGNAL)
unnamed: C5.2, L1.1, U1.2 (LNA)
unnamed: C8.2, U1.27 (XTAL_OUT), Y1.3
unnamed: C9.2, U1.28 (XTAL_IN), Y1.1
unnamed: D1.2 (A), R2.2
unnamed: D2.2 (A), R5.2
unnamed: D3.2 (A), R6.2
unnamed: R3.2, U1.31 (RES12K)
unnamed: R8.2, R9.2, SW1.1
unnamed: R10.2, SW2.1
unnamed: R13.1, U2.7 (HOLD)
unnamed: R14.1, U2.3 (WP)
unnamed: R15.1, U2.6 (CLK)

Notes on the sheet:
GPIO0
GPIO13
GPIO12
GPIO11
USB-TTL
RSV
GPIO7
CLK
管脚 名称 类型 GPIO 功能 15 GPIO0 I/O GPIO0 SPI_CS2 26 U0TXD I/O GPIO1 可⽤作烧写 Flash 时 UART Tx；SPI_CS1 14 GPIO2 I/O GPIO2 可⽤作烧写 Flash 时 UART1_TX 25 U0RXD I/O GPIO3 可⽤作烧写 Flash 时 UART Rx 16 GPIO4 I/O GPIO4 24 GPIO5 I/O GPIO5 21 SDIO_CLK I/O GPIO6 连接到 SD_CLK（串联 200Ω）；SPI_CLK 22 SDIO_DATA_0 I/O GPIO7 连接到 SD_D0（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
GPIO10
SD0
GPIO3
注意：（每次启动、重启、唤醒） GPIO15 必须保持低电平，GPIO2 必须 保持高电平 GPIO0 高电平->运行模式，低电平->刷写模式 如果需要用到sleep 模式，GPIO16 和 RST 必须连接， GPIO16 会输出低电平唤醒系统
GPIO1
GPIO8
POWER
FLASH
SD3
PIO15
GPIO14
RUN-MODULE
CMD
GPIO2
GPIO4
GPIO9
SD1
D10
CONNECT
GPIO15
ESP-8266EX
GPIO16
GPIO5
LED
KEY
PIN
esp8266 datasheet
管脚 名称 类型 功能 1 VDDA P 模拟电源 2.5V ~ 3.6V 2 LNA I/O 射频天线接⼝，芯⽚输出阻抗为 39+j6 Ω。建议保留 π 型匹配⽹络对天线进⾏匹配。 3 VDD3P3 P 功放电源 2.5V ~ 3.6V 4 VDD3P3 P 功放电源 2.5V ~ 3.6V 5 VDD_RTC P NC (1.1V) 6 TOUT I ADC 端⼝（注：芯⽚内部 ADC 端⼝），可⽤于检测 VDD3P3 (Pin3,Pin4) 电源电压和 TOUT (Pin6) 的输⼊电压（⼆者不可同时使⽤）。 7 CHIP_PU I 芯⽚使能端。⾼电平：有效，芯⽚正常⼯作；低电平：芯⽚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
SD2
GPIO14

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
Board: 4 copper layers, 29.2 x 45.2 mm, 37 parts (0 on the bottom side), 35 nets.
